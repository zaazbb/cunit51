# Keil uVision project example.uvproj, settings and files
target Target 1 (MCS-51)
  device: R8051XC CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: example
  c flags: Optimize=8 SizeSpeed=1
  c define: stdout=0 stderr=0 FILE=char fprintf=printf setvbuf _IONBF=0 exit EXIT_FAILURE=0 snprintf=sprintf
  c include: ..\..\CUnit-2.1-3\CUnit\Headers;..\..\CUnit-2.1-3\Examples;..\..\src\inc
  group Source Group 1
    ./: STARTUP.A51
  group cunit
    ../../CUnit-2.1-3/CUnit/Sources/Basic/: Basic.c
    ../../CUnit-2.1-3/CUnit/Sources/Framework/: CUError.c MyMem.c TestDB.c TestRun.c Util.c
  group example
    ../../CUnit-2.1-3/Examples/BasicTest/: BasicTest.c
    ../../CUnit-2.1-3/Examples/: ExampleTests.c
